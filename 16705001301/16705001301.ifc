Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-05T11:07:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Nov 05 11:07:25 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{14F87E97-2750-4BFF-8796-972BBCFC8E93}\ifc * Database version: 5507 * Database creation date: Sun Nov 05 11:07:25 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Nov 05 11:07:25 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Nov 05 11:07:25 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted, 16705001301:dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted:194079
In: Level 1
Pset_BuildingElementProxyCommon - Reference: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted
Pset_ManufacturerTypeInformation - ModelReference: 45-35-72/372; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1; Default Elevation: 1219.2 mm
Dimensions - Area: 0.00947778 m2; Volume: 0.000065267 m3; BarDiameter: 14 mm; Overhang: 46 mm; Protrusion: 68 mm; ShelfBendRadius: 7 mm; ShelfDepth: 62.5466 mm; ShelfWidth: 75 mm; Thickness: 1.5 mm; Width: 300 mm
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Generic Models; Family: 16705001301: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted; Family and Type: 16705001301: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 16705001301: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted; Type Id: 16705001301: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted; WarrantyStartDate: 1900-12-31T23:59:59; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: n/a; Constituents: Towel rail; DurationUnit: year; ExpectedLife: 20 years; Family Name: 16705001301; Features: n/a; Finish: Polished; Grade: n/a; Material: AISI 326 stainless steel; ModelNumber: n/a; ModelReference: 45-35-72/372; Name: TowelRail_Polished_14x300x75_BushMounted; ReplacementCost: n/a; Shape: n/a; Size: 300 x 14 x 75 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
Phasing - Phase Created: New Construction
General - Author: Gytautas Balevičius; BIMObjectName: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 10 28 16; MasterFormat2014Description: Bath Accessories; NBSCertification: n/a; NBSDescription: Towel rails; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/372; NBSTypeID: n/a; OmniclassCode: 23-31 25 00; OmniclassDescription: Toilet and Bath Specialties; ProductFamily: Sanitary; ProductGroup: Towel rail; ProductInformation: http://dline.com/product/knud-holscher-collection-towel-rail/?attribute_pa_material=polished-stainless-steel-aisi-316&attribute_pa_diameter=14&attribute_pa_item=14-x-300-mm-bush-polished#; ProductionCountry: Lithuania; ProductSKU: 16705001301; Revision: n/a; Uniclass2015Code: Pr_40_20_76_90; Uniclass2015Title: Towel rails; Uniclass2015Version: Products v1.5; UNSPSCCode: 30181602; Version: 1; Weight Net (kg): 0
Identity Data - Description: AISI 316 stainless steel towel rail; Manufacturer: info@dline.com; Type Name: dline_Sanitary_TowelRail_Polished_14x300x75_BushMounted
Materials and Finishes - MainMaterial: AISI 316
